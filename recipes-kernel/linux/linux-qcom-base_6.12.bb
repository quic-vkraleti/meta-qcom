
require recipes-kernel/linux/linux-qcom.inc

